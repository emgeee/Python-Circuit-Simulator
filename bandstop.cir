* gnetlist -g spice-sdb -o bandstop.cir bandstop.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
V1 1 0 5
C1 0 2 2.2uF
L1 2 1 10mH
R1 1 0 750
.end
