* gnetlist -g spice-sdb -o parallel_rlc.cir parallel_rlc.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
C1 0 1 1uF
L1 0 1 50mH
R1 0 1 500
V1 1 0 5
.end
