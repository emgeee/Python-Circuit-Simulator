* gnetlist -g spice-sdb -o low-pass.cir low-pass.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
V1 2 0 5
C1 0 1 2.2uF
L1 2 1 10mH
R1 1 0 750
.end
