* gnetlist -g spice-sdb -o bandpass_rc.cir bandpass_rc.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
C2 0 3 4uf
R2 1 3 1k
V1 2 0 5
C1 1 2 2.2uF
R1 1 0 750
.end
